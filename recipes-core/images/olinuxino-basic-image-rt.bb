include olinuxino-hwup-image-rt.bb

IMAGE_FEATURES += "ssh-server-dropbear"

